IMAGE_INSTALL += "packagegroup-core-buildessential"

IMAGE_INSTALL += "zeromq-dev"
IMAGE_INSTALL += "rsmb"
IMAGE_INSTALL += "nodejs"
IMAGE_INSTALL += "paho-mqtt-dev"
IMAGE_INSTALL += "mdns-dev"
IMAGE_INSTALL += "iotkit-comm-js"
IMAGE_INSTALL += "iotkit-comm-c-dev"
IMAGE_INSTALL += "iotkit-agent"
IMAGE_INSTALL += "xdk-daemon"
IMAGE_INSTALL += "oobe"

# MRAA
IMAGE_INSTALL += "mraa-dev"
IMAGE_INSTALL += "mraa-doc"

# UPM
IMAGE_INSTALL += "upm-dev"
